Commit message: limit

File: supre_robot/rf2502_new_3_std.urdf (robot description, URDF)
Before this commit: robot rf2502_new_3, 21 links, 20 joints
Joints:
- joint arml_joint3: limit lower=-0.1745 upper=1.9198 effort=0 velocity=0 -> lower=-1.9198 upper=1.9198 effort=0 velocity=0
